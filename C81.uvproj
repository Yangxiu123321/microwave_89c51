# Keil uVision project C81.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: C81 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source Group 1
    ./: STARTUP.A51
  group source
    ./src/: main.c PIO_1.c gpio.c stepMotor.c delay.c timer.c 89C51_it.c usart.c HD7279.c 8255.c 8254.c key.c adc.c
